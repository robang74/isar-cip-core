#
# CIP Core, generic profile
#
# Copyright (c) Siemens AG, 2022
#
# Authors:
#  Jan Kiszka <jan.kiszka@siemens.com>
#
# SPDX-License-Identifier: MIT
#

require u-boot-qemu-common.inc

U_BOOT_CONFIG = "qemu_arm_defconfig"

EFI_ARCH = "arm"
