#
# CIP Core, generic profile
#
# Copyright (c) Siemens AG, 2022
#
# Authors:
#  Jan Kiszka <jan.kiszka@siemens.com>
#
# SPDX-License-Identifier: MIT
#

require secure-boot-secrets.inc

DEBIAN_CONFLICTS = "secure-boot-snakeoil"
